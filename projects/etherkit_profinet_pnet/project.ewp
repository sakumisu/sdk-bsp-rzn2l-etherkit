# IAR project project.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: R9A07G084M04 Renesas R9A07G084M04
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 49
  General.FPU2: 8
  ICCARM.CCDefines: _LWIP_ADD_ON_APP=0; ETHERCAT_SSC_PORT_GMAC_MDIO_SUPPORT=1; CLOCKS_PER_SEC=RT_TICK_PER_SECOND; RT_USING_DLIBC; RT_USING_LIBC; _DLIB_ADD_EXTRA_SYMBOLS=0; __RTTHREAD__; __RT_IPC_SOURCE__; __RT_KERNEL_SOURCE__; _RZN_ORDINAL=1; _RZN_CORE=CR52_0; _RENESAS_RZN_
  ICCARM.CCIncludePath2: rzn/arm/CMSIS_5/CMSIS/Core_R/Include; rzn/aws/amazon-freertos/freertos_kernel/include; rzn/fsp/inc; rzn/fsp/inc/api; rzn/fsp/inc/instances; rzn/fsp/src/bsp/mcu/all/cr; rzn/fsp/src/rm_ethercat_ssc_port; rzn/fsp/src/rm_freertos_port/cr; rzn_cfg/aws; rzn_cfg/fsp_cfg; rzn_cfg/fsp_cfg/bsp; rzn_gen; src; $PROJ_DIR$; src\ethercat\beckhoff\Src; src\ethercat\renesas; src\tcpip\renesas\module; src\tcpip\renesas\module\ether_netif; src\tcpip\renesas\module\lwip_port; src\tcpip\renesas\module\serial_io; src\tcpip\renesas\oss_deps\lwip; src\tcpip\oss\amazon-freertos\libraries\3rdparty\lwip_osal\include; src\tcpip\oss\lwip\src\include; rt-thread\components\drivers\include; rt-thread\libcpu\arm\common; .; rt-thread\components\libc\posix\io\eventfd; rt-thread\components\libc\posix\io\poll; board\ports; libraries\HAL_Drivers\config; rt-thread\components\libc\posix\io\epoll; rt-thread\components\libc\compilers\common\extension\fcntl\octal; rt-thread\components\libc\posix\ipc; rt-thread\libcpu\arm\cortex-r52; libraries\HAL_Drivers; rt-thread\components\libc\compilers\common\extension; board; rt-thread\components\libc\compilers\common\include; rt-thread\components\libc\cplusplus; rt-thread\components\finsh; rt-thread\include
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.ADefines: _RZN_ORDINAL=1; _RZN_CORE=CR52_0; _RENESAS_RZN_
  AARM.AUserIncludes: rzn/arm/CMSIS_5/CMSIS/Core_R/Include; rzn/aws/amazon-freertos/freertos_kernel/include; rzn/fsp/inc; rzn/fsp/inc/api; rzn/fsp/inc/instances; rzn/fsp/src/bsp/mcu/all/cr; rzn/fsp/src/rm_ethercat_ssc_port; rzn/fsp/src/rm_freertos_port/cr; rzn_cfg/aws; rzn_cfg/fsp_cfg; rzn_cfg/fsp_cfg/bsp; rzn_gen; src; $PROJ_DIR$
  OBJCOPY.OOCOutputFile: project.srec
  ILINK.IlinkOutputFile: template.out
  ILINK.IlinkIcfFile: script/fsp_xspi0_boot.icf
  ILINK.IlinkExtraOptions: --config_search "$PROJ_DIR$"
  ILINK.IlinkProgramEntryLabel: system_init
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG; CLOCKS_PER_SEC=RT_TICK_PER_SECOND; RT_USING_DLIBC; RT_USING_LIBC; _DLIB_ADD_EXTRA_SYMBOLS=0; __RTTHREAD__; __RT_IPC_SOURCE__; __RT_KERNEL_SOURCE__; _RZN_ORDINAL=1; _RZN_CORE=CR52_0; _RENESAS_RZN_
  ICCARM.CCIncludePath2: rzn/arm/CMSIS_5/CMSIS/Core_R/Include; rzn/aws/amazon-freertos/freertos_kernel/include; rzn/fsp/inc; rzn/fsp/inc/api; rzn/fsp/inc/instances; rzn/fsp/src/bsp/mcu/all/cr; rzn/fsp/src/rm_ethercat_ssc_port; rzn/fsp/src/rm_freertos_port/cr; rzn_cfg/aws; rzn_cfg/fsp_cfg; rzn_cfg/fsp_cfg/bsp; rzn_gen; src; $PROJ_DIR$; rt-thread\components\drivers\include; rt-thread\libcpu\arm\common; .; rt-thread\components\libc\posix\io\eventfd; rt-thread\components\libc\posix\io\poll; board\ports; libraries\HAL_Drivers\config; rt-thread\components\libc\posix\io\epoll; rt-thread\components\libc\compilers\common\extension\fcntl\octal; rt-thread\components\libc\posix\ipc; rt-thread\libcpu\arm\cortex-r52; libraries\HAL_Drivers; rt-thread\components\libc\compilers\common\extension; board; rt-thread\components\libc\compilers\common\include; rt-thread\components\libc\cplusplus; rt-thread\components\finsh; rt-thread\include
  ICCARM.CCOptLevel: 3
  ICCARM.IccLang: 0
  group (top)
    ./: buildinfo.ipcf
  group Compiler
    rt-thread/components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
    rt-thread/components/libc/compilers/dlib/: environ.c syscall_close.c syscall_lseek.c syscall_mem.c syscall_open.c syscall_read.c syscall_remove.c syscall_write.c syscalls.c
  group CPP
    rt-thread/components/libc/cplusplus/: cxx_crt.cpp cxx_crt_init.c
  group CPU
    rt-thread/libcpu/arm/cortex-r52/: backtrace.c context_iar.S cpuport.c gicv3.c interrupt.c stack.c start_iar.S trap.c vector_iar.S
  group DeviceDrivers
    rt-thread/components/drivers/ipc/: completion.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    rt-thread/components/drivers/core/: device.c
    rt-thread/components/drivers/pin/: pin.c
    rt-thread/components/drivers/serial/: serial_v2.c
  group Drivers
    libraries/HAL_Drivers/: drv_common.c drv_gpio.c drv_usart_v2.c
  group Finsh
    rt-thread/components/finsh/: cmd.c msh.c msh_parse.c shell.c
  group Flex Software/Build Configuration
    rzn_cfg/fsp_cfg/bsp/: board_cfg.h bsp_cfg.h bsp_mcu_device_cfg.h bsp_mcu_device_memory_cfg.h bsp_mcu_device_pn_cfg.h bsp_mcu_family_cfg.h bsp_memory_cfg.h bsp_pin_cfg.h
    rzn_cfg/fsp_cfg/: r_ioport_cfg.h r_sci_uart_cfg.h
    rzn_cfg/: SConscript
  group Flex Software/Components
    rzn/board/rzn2l_rsk/: board.h board_ethernet_phy.h board_init.c board_init.h board_leds.c board_leds.h
    rzn/fsp/inc/api/: bsp_api.h r_ioport_api.h r_transfer_api.h r_uart_api.h
    rzn/fsp/src/bsp/mcu/all/: bsp_cache.c bsp_cache.h bsp_cache.o bsp_clocks.c bsp_clocks.h bsp_clocks.o bsp_common.c bsp_common.h bsp_common.o bsp_compiler_support.h bsp_delay.c bsp_delay.h bsp_delay.o bsp_exceptions.h bsp_io.c bsp_io.h bsp_io.o bsp_irq.c bsp_irq.h bsp_irq.o bsp_mcu_api.h bsp_module_stop.h bsp_register_protection.c bsp_register_protection.h bsp_register_protection.o bsp_reset.c bsp_reset.h bsp_reset.o bsp_sbrk.c bsp_sbrk.o bsp_tfu.h
    rzn/fsp/src/bsp/mcu/all/cr/: bsp_cache_core.c bsp_cache_core.h bsp_cache_core.o bsp_delay_core.c bsp_delay_core.h bsp_delay_core.o bsp_irq_core.c bsp_irq_core.h bsp_irq_core.o
    rzn/fsp/src/bsp/mcu/rzn2l/: bsp_elc.h bsp_feature.h bsp_irq_sense.c bsp_irq_sense.o bsp_loader_param.c bsp_loader_param.o bsp_mcu_info.h bsp_override.h
    rzn/arm/CMSIS_5/CMSIS/Core_R/Include/: cmsis_compiler.h cmsis_cp15.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_cr52.h
    rzn/fsp/inc/: fsp_common_api.h fsp_features.h fsp_version.h
    rzn/arm/CMSIS_5/: LICENSE.txt
    rzn/fsp/src/bsp/cmsis/Device/RENESAS/Include/: R9A07G084.h renesas.h system.h
    rzn/fsp/src/r_ioport/: r_ioport.c r_ioport.o
    rzn/fsp/inc/instances/: r_ioport.h r_sci_uart.h
    rzn/fsp/src/r_sci_uart/: r_sci_uart.c r_sci_uart.o
    rzn/: SConscript
    rzn/fsp/src/bsp/cmsis/Device/RENESAS/Source/: startup.c startup.o system.c system.o
    rzn/fsp/src/bsp/cmsis/Device/RENESAS/Source/cr/: startup_core.c startup_core.o system_core.c system_core.o
  group Flex Software/Generated Data
    rzn_gen/: bsp_clock_cfg.h common_data.c common_data.h hal_data.c hal_data.h main.c pin_data.c SConscript vector_data.c vector_data.h
  group Flex Software/Program Entry
    src/: hal_entry.c
  group Kernel
    rt-thread/src/: clock.c components.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
    rt-thread/src/klibc/: kstdio.c kstring.c
  group libcpu
    rt-thread/libcpu/arm/common/: atomic_arm.c div0.c showmem.c
